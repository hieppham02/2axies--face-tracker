<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Robot-Arm_Demo.ewp</path>
  </project>
  <batchBuild />
</workspace>
